FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Woody-first-change.patch \
            file://0001-Woody-second-change.patch \
            "

