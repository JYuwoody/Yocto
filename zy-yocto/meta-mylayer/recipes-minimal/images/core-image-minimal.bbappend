IMAGE_INSTALL += "hello hello-m hello-c testapphello alsa-utils hello-mod"
