inherit externalsrc
EXTERNALSRC = "/home/woody/Desktop/yocto/hellopoky"
